**********************************************************
* THIS FILE IS GENERATED BY AIVALANCHE
* FILE ID: 1
* SIMULATION TYPE: dc_sweep
**********************************************************

* Define the temperature
.TEMP 40.0

* Include the dut file
.INCLUDE /home/gazi/Desktop/Work/custom_packages/calibration/src/templates/diode/dut.cir

** Start testbenches

********************* dut testbench 0_1 *********************
e_v_0_1 p_0_1 0 v_sweep 0 1
v_meas_0_1 n_0_1 0 0
x_0_1 p_0_1 n_0_1 dut area=2e-06 m=1.0
*************************************************************

********************* dut testbench 1_1 *********************
e_v_1_1 p_1_1 0 v_sweep 0 1
v_meas_1_1 n_1_1 0 0
x_1_1 p_1_1 n_1_1 dut area=5e-07 m=1.0
*************************************************************

** End testbenches

* Declare the v_sweep, which will change during the simulation.
v_sweep v_sweep 0 0

********** Start of control section **********
.control

** Model parameters start
alterparam dut is = 1.301988003655862e-19
alterparam dut jsw = 5.2456790695993e-15
alterparam dut n = 1.6721853351291618
alterparam dut rs = 0.1352820608747862
alterparam dut bv = 3.813323474245202e+18
alterparam dut ibv = 9.134701331962986e-06
alterparam dut nbv = 1.4074258070593935
alterparam dut ikf = 3.821714605411962e-06
alterparam dut ikr = 1.505498238739193e-05
alterparam dut trs1 = 1*-0.005520461031660879
alterparam dut trs2 = 1*-0.000488663832858705
reset
** Model parameters end

** Declare the vectors to save.
save v(p_0_1) v(p_1_1) i(v_meas_0_1) i(v_meas_1_1)

** Run the dc sweep analysis.
dc v_sweep -0.2 3.5 0.1

** Save the output to file.
set wr_vecnames
set wr_singlescale
wrdata /home/gazi/Desktop/Work/custom_packages/calibration/test/diode/results/calibration_2023-06-26_20:45:10/simulation_files/dc_sweep_1.csv v(p_0_1) v(p_1_1) i(v_meas_0_1) i(v_meas_1_1)

.endc
********** End of control section **********

.end
