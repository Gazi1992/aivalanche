**********************************************************
* THIS FILE IS GENERATED BY AIVALANCHE
* FILE ID: 7
* SIMULATION TYPE: dc_sweep
**********************************************************

* Define the temperature
.TEMP 25.0

* Include the dut file
.INCLUDE /home/gazi/Desktop/Work/custom_packages/calibration/src/templates/mosfet_level_1/nmos/dut.cir

** Start testbenches

********************* dut testbench 10_0 *********************
v_ds_10_0 d_10_0 0 0.05
e_gs_10_0 g_10_0 0 v_sweep 0 1
v_s_10_0 s_10_0 0 0
v_bs_10_0 b_10_0 0 -1.0
x_10_0 d_10_0 g_10_0 s_10_0 b_10_0 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 10_1 *********************
v_ds_10_1 d_10_1 0 0.05
e_gs_10_1 g_10_1 0 v_sweep 0 1
v_s_10_1 s_10_1 0 0
v_bs_10_1 b_10_1 0 -0.75
x_10_1 d_10_1 g_10_1 s_10_1 b_10_1 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 10_2 *********************
v_ds_10_2 d_10_2 0 0.05
e_gs_10_2 g_10_2 0 v_sweep 0 1
v_s_10_2 s_10_2 0 0
v_bs_10_2 b_10_2 0 -0.5
x_10_2 d_10_2 g_10_2 s_10_2 b_10_2 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 10_3 *********************
v_ds_10_3 d_10_3 0 0.05
e_gs_10_3 g_10_3 0 v_sweep 0 1
v_s_10_3 s_10_3 0 0
v_bs_10_3 b_10_3 0 -0.25
x_10_3 d_10_3 g_10_3 s_10_3 b_10_3 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 10_4 *********************
v_ds_10_4 d_10_4 0 0.05
e_gs_10_4 g_10_4 0 v_sweep 0 1
v_s_10_4 s_10_4 0 0
v_bs_10_4 b_10_4 0 0.0
x_10_4 d_10_4 g_10_4 s_10_4 b_10_4 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 11_0 *********************
v_ds_11_0 d_11_0 0 1.6
e_gs_11_0 g_11_0 0 v_sweep 0 1
v_s_11_0 s_11_0 0 0
v_bs_11_0 b_11_0 0 -1.0
x_11_0 d_11_0 g_11_0 s_11_0 b_11_0 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 11_1 *********************
v_ds_11_1 d_11_1 0 1.6
e_gs_11_1 g_11_1 0 v_sweep 0 1
v_s_11_1 s_11_1 0 0
v_bs_11_1 b_11_1 0 -0.75
x_11_1 d_11_1 g_11_1 s_11_1 b_11_1 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 11_2 *********************
v_ds_11_2 d_11_2 0 1.6
e_gs_11_2 g_11_2 0 v_sweep 0 1
v_s_11_2 s_11_2 0 0
v_bs_11_2 b_11_2 0 -0.5
x_11_2 d_11_2 g_11_2 s_11_2 b_11_2 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 11_3 *********************
v_ds_11_3 d_11_3 0 1.6
e_gs_11_3 g_11_3 0 v_sweep 0 1
v_s_11_3 s_11_3 0 0
v_bs_11_3 b_11_3 0 -0.25
x_11_3 d_11_3 g_11_3 s_11_3 b_11_3 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 11_4 *********************
v_ds_11_4 d_11_4 0 1.6
e_gs_11_4 g_11_4 0 v_sweep 0 1
v_s_11_4 s_11_4 0 0
v_bs_11_4 b_11_4 0 0.0
x_11_4 d_11_4 g_11_4 s_11_4 b_11_4 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 12_0 *********************
v_ds_12_0 d_12_0 0 0.05
e_gs_12_0 g_12_0 0 v_sweep 0 1
v_s_12_0 s_12_0 0 0
v_bs_12_0 b_12_0 0 -1.0
x_12_0 d_12_0 g_12_0 s_12_0 b_12_0 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 12_1 *********************
v_ds_12_1 d_12_1 0 0.05
e_gs_12_1 g_12_1 0 v_sweep 0 1
v_s_12_1 s_12_1 0 0
v_bs_12_1 b_12_1 0 -0.75
x_12_1 d_12_1 g_12_1 s_12_1 b_12_1 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 12_2 *********************
v_ds_12_2 d_12_2 0 0.05
e_gs_12_2 g_12_2 0 v_sweep 0 1
v_s_12_2 s_12_2 0 0
v_bs_12_2 b_12_2 0 -0.5
x_12_2 d_12_2 g_12_2 s_12_2 b_12_2 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 12_3 *********************
v_ds_12_3 d_12_3 0 0.05
e_gs_12_3 g_12_3 0 v_sweep 0 1
v_s_12_3 s_12_3 0 0
v_bs_12_3 b_12_3 0 -0.25
x_12_3 d_12_3 g_12_3 s_12_3 b_12_3 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 12_4 *********************
v_ds_12_4 d_12_4 0 0.05
e_gs_12_4 g_12_4 0 v_sweep 0 1
v_s_12_4 s_12_4 0 0
v_bs_12_4 b_12_4 0 0.0
x_12_4 d_12_4 g_12_4 s_12_4 b_12_4 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 13_0 *********************
v_ds_13_0 d_13_0 0 1.6
e_gs_13_0 g_13_0 0 v_sweep 0 1
v_s_13_0 s_13_0 0 0
v_bs_13_0 b_13_0 0 -1.0
x_13_0 d_13_0 g_13_0 s_13_0 b_13_0 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 13_1 *********************
v_ds_13_1 d_13_1 0 1.6
e_gs_13_1 g_13_1 0 v_sweep 0 1
v_s_13_1 s_13_1 0 0
v_bs_13_1 b_13_1 0 -0.75
x_13_1 d_13_1 g_13_1 s_13_1 b_13_1 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 13_2 *********************
v_ds_13_2 d_13_2 0 1.6
e_gs_13_2 g_13_2 0 v_sweep 0 1
v_s_13_2 s_13_2 0 0
v_bs_13_2 b_13_2 0 -0.5
x_13_2 d_13_2 g_13_2 s_13_2 b_13_2 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 13_3 *********************
v_ds_13_3 d_13_3 0 1.6
e_gs_13_3 g_13_3 0 v_sweep 0 1
v_s_13_3 s_13_3 0 0
v_bs_13_3 b_13_3 0 -0.25
x_13_3 d_13_3 g_13_3 s_13_3 b_13_3 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 13_4 *********************
v_ds_13_4 d_13_4 0 1.6
e_gs_13_4 g_13_4 0 v_sweep 0 1
v_s_13_4 s_13_4 0 0
v_bs_13_4 b_13_4 0 0.0
x_13_4 d_13_4 g_13_4 s_13_4 b_13_4 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 14_0 *********************
v_ds_14_0 d_14_0 0 0.05
e_gs_14_0 g_14_0 0 v_sweep 0 1
v_s_14_0 s_14_0 0 0
v_bs_14_0 b_14_0 0 -1.0
x_14_0 d_14_0 g_14_0 s_14_0 b_14_0 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 14_1 *********************
v_ds_14_1 d_14_1 0 0.05
e_gs_14_1 g_14_1 0 v_sweep 0 1
v_s_14_1 s_14_1 0 0
v_bs_14_1 b_14_1 0 -0.75
x_14_1 d_14_1 g_14_1 s_14_1 b_14_1 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 14_2 *********************
v_ds_14_2 d_14_2 0 0.05
e_gs_14_2 g_14_2 0 v_sweep 0 1
v_s_14_2 s_14_2 0 0
v_bs_14_2 b_14_2 0 -0.5
x_14_2 d_14_2 g_14_2 s_14_2 b_14_2 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 14_3 *********************
v_ds_14_3 d_14_3 0 0.05
e_gs_14_3 g_14_3 0 v_sweep 0 1
v_s_14_3 s_14_3 0 0
v_bs_14_3 b_14_3 0 -0.25
x_14_3 d_14_3 g_14_3 s_14_3 b_14_3 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 14_4 *********************
v_ds_14_4 d_14_4 0 0.05
e_gs_14_4 g_14_4 0 v_sweep 0 1
v_s_14_4 s_14_4 0 0
v_bs_14_4 b_14_4 0 0.0
x_14_4 d_14_4 g_14_4 s_14_4 b_14_4 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 15_0 *********************
v_ds_15_0 d_15_0 0 1.6
e_gs_15_0 g_15_0 0 v_sweep 0 1
v_s_15_0 s_15_0 0 0
v_bs_15_0 b_15_0 0 -1.0
x_15_0 d_15_0 g_15_0 s_15_0 b_15_0 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 15_1 *********************
v_ds_15_1 d_15_1 0 1.6
e_gs_15_1 g_15_1 0 v_sweep 0 1
v_s_15_1 s_15_1 0 0
v_bs_15_1 b_15_1 0 -0.75
x_15_1 d_15_1 g_15_1 s_15_1 b_15_1 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 15_2 *********************
v_ds_15_2 d_15_2 0 1.6
e_gs_15_2 g_15_2 0 v_sweep 0 1
v_s_15_2 s_15_2 0 0
v_bs_15_2 b_15_2 0 -0.5
x_15_2 d_15_2 g_15_2 s_15_2 b_15_2 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 15_3 *********************
v_ds_15_3 d_15_3 0 1.6
e_gs_15_3 g_15_3 0 v_sweep 0 1
v_s_15_3 s_15_3 0 0
v_bs_15_3 b_15_3 0 -0.25
x_15_3 d_15_3 g_15_3 s_15_3 b_15_3 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 15_4 *********************
v_ds_15_4 d_15_4 0 1.6
e_gs_15_4 g_15_4 0 v_sweep 0 1
v_s_15_4 s_15_4 0 0
v_bs_15_4 b_15_4 0 0.0
x_15_4 d_15_4 g_15_4 s_15_4 b_15_4 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 16_0 *********************
v_ds_16_0 d_16_0 0 0.05
e_gs_16_0 g_16_0 0 v_sweep 0 1
v_s_16_0 s_16_0 0 0
v_bs_16_0 b_16_0 0 -1.0
x_16_0 d_16_0 g_16_0 s_16_0 b_16_0 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 16_1 *********************
v_ds_16_1 d_16_1 0 0.05
e_gs_16_1 g_16_1 0 v_sweep 0 1
v_s_16_1 s_16_1 0 0
v_bs_16_1 b_16_1 0 -0.75
x_16_1 d_16_1 g_16_1 s_16_1 b_16_1 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 16_2 *********************
v_ds_16_2 d_16_2 0 0.05
e_gs_16_2 g_16_2 0 v_sweep 0 1
v_s_16_2 s_16_2 0 0
v_bs_16_2 b_16_2 0 -0.5
x_16_2 d_16_2 g_16_2 s_16_2 b_16_2 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 16_3 *********************
v_ds_16_3 d_16_3 0 0.05
e_gs_16_3 g_16_3 0 v_sweep 0 1
v_s_16_3 s_16_3 0 0
v_bs_16_3 b_16_3 0 -0.25
x_16_3 d_16_3 g_16_3 s_16_3 b_16_3 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 16_4 *********************
v_ds_16_4 d_16_4 0 0.05
e_gs_16_4 g_16_4 0 v_sweep 0 1
v_s_16_4 s_16_4 0 0
v_bs_16_4 b_16_4 0 0.0
x_16_4 d_16_4 g_16_4 s_16_4 b_16_4 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 17_0 *********************
v_ds_17_0 d_17_0 0 1.6
e_gs_17_0 g_17_0 0 v_sweep 0 1
v_s_17_0 s_17_0 0 0
v_bs_17_0 b_17_0 0 -1.0
x_17_0 d_17_0 g_17_0 s_17_0 b_17_0 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 17_1 *********************
v_ds_17_1 d_17_1 0 1.6
e_gs_17_1 g_17_1 0 v_sweep 0 1
v_s_17_1 s_17_1 0 0
v_bs_17_1 b_17_1 0 -0.75
x_17_1 d_17_1 g_17_1 s_17_1 b_17_1 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 17_2 *********************
v_ds_17_2 d_17_2 0 1.6
e_gs_17_2 g_17_2 0 v_sweep 0 1
v_s_17_2 s_17_2 0 0
v_bs_17_2 b_17_2 0 -0.5
x_17_2 d_17_2 g_17_2 s_17_2 b_17_2 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 17_3 *********************
v_ds_17_3 d_17_3 0 1.6
e_gs_17_3 g_17_3 0 v_sweep 0 1
v_s_17_3 s_17_3 0 0
v_bs_17_3 b_17_3 0 -0.25
x_17_3 d_17_3 g_17_3 s_17_3 b_17_3 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 17_4 *********************
v_ds_17_4 d_17_4 0 1.6
e_gs_17_4 g_17_4 0 v_sweep 0 1
v_s_17_4 s_17_4 0 0
v_bs_17_4 b_17_4 0 0.0
x_17_4 d_17_4 g_17_4 s_17_4 b_17_4 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 18_0 *********************
v_ds_18_0 d_18_0 0 0.05
e_gs_18_0 g_18_0 0 v_sweep 0 1
v_s_18_0 s_18_0 0 0
v_bs_18_0 b_18_0 0 -1.0
x_18_0 d_18_0 g_18_0 s_18_0 b_18_0 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 18_1 *********************
v_ds_18_1 d_18_1 0 0.05
e_gs_18_1 g_18_1 0 v_sweep 0 1
v_s_18_1 s_18_1 0 0
v_bs_18_1 b_18_1 0 -0.75
x_18_1 d_18_1 g_18_1 s_18_1 b_18_1 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 18_2 *********************
v_ds_18_2 d_18_2 0 0.05
e_gs_18_2 g_18_2 0 v_sweep 0 1
v_s_18_2 s_18_2 0 0
v_bs_18_2 b_18_2 0 -0.5
x_18_2 d_18_2 g_18_2 s_18_2 b_18_2 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 18_3 *********************
v_ds_18_3 d_18_3 0 0.05
e_gs_18_3 g_18_3 0 v_sweep 0 1
v_s_18_3 s_18_3 0 0
v_bs_18_3 b_18_3 0 -0.25
x_18_3 d_18_3 g_18_3 s_18_3 b_18_3 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 18_4 *********************
v_ds_18_4 d_18_4 0 0.05
e_gs_18_4 g_18_4 0 v_sweep 0 1
v_s_18_4 s_18_4 0 0
v_bs_18_4 b_18_4 0 0.0
x_18_4 d_18_4 g_18_4 s_18_4 b_18_4 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 19_0 *********************
v_ds_19_0 d_19_0 0 1.6
e_gs_19_0 g_19_0 0 v_sweep 0 1
v_s_19_0 s_19_0 0 0
v_bs_19_0 b_19_0 0 -1.0
x_19_0 d_19_0 g_19_0 s_19_0 b_19_0 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 19_1 *********************
v_ds_19_1 d_19_1 0 1.6
e_gs_19_1 g_19_1 0 v_sweep 0 1
v_s_19_1 s_19_1 0 0
v_bs_19_1 b_19_1 0 -0.75
x_19_1 d_19_1 g_19_1 s_19_1 b_19_1 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 19_2 *********************
v_ds_19_2 d_19_2 0 1.6
e_gs_19_2 g_19_2 0 v_sweep 0 1
v_s_19_2 s_19_2 0 0
v_bs_19_2 b_19_2 0 -0.5
x_19_2 d_19_2 g_19_2 s_19_2 b_19_2 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 19_3 *********************
v_ds_19_3 d_19_3 0 1.6
e_gs_19_3 g_19_3 0 v_sweep 0 1
v_s_19_3 s_19_3 0 0
v_bs_19_3 b_19_3 0 -0.25
x_19_3 d_19_3 g_19_3 s_19_3 b_19_3 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 19_4 *********************
v_ds_19_4 d_19_4 0 1.6
e_gs_19_4 g_19_4 0 v_sweep 0 1
v_s_19_4 s_19_4 0 0
v_bs_19_4 b_19_4 0 0.0
x_19_4 d_19_4 g_19_4 s_19_4 b_19_4 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

** End testbenches

* Declare the v_sweep, which will change during the simulation.
v_sweep v_sweep 0 0

********** Start of control section **********
.control

** Model parameters start
alterparam dut vto = 0.5560696417388288
alterparam dut kp = 0.00022973654374805466
alterparam dut gamma = 0.02895741901434129
alterparam dut phi = 0.05791483802868258
alterparam dut rd = 1.4278982751990845
alterparam dut rs = 0.11582967605736516
alterparam dut cbd = 1.484336816360469e-19
alterparam dut cbs = 1.8904523865005416e-20
alterparam dut is = 1.8328582900325297e-15
alterparam dut pb = 0.7902812684659888
alterparam dut cgso = 3.794446032038467e-20
alterparam dut cgdo = 1.3320956719293494e-18
alterparam dut cgbo = 2.36720991735245e-17
alterparam dut rsh = 5.6902562132561325
alterparam dut cj = 6.073727792518479e-07
alterparam dut mj = 0.3313971778070685
alterparam dut cjsw = 2.5433367473226856e-15
alterparam dut mjsw = 0.05791483802868258
alterparam dut tox = 2.62456449268145e-07
alterparam dut nsub = 8.020695857269856e+17
alterparam dut nss = 569044731273731.6
alterparam dut nfs = 11524517181.039333
alterparam dut tpg = 2.6909747893168894
alterparam dut xj = 3.794446032038483e-15
alterparam dut ld = 3.0563904911705027e-09
alterparam dut uo = 458.4213508018038
alterparam dut vmax = 1467.6005787759975
alterparam dut kf = 3.794446032038467e-30
alterparam dut af = 0.2895741901434129
alterparam dut fc = 2.650009826950765
reset
** Model parameters end

** Declare the vectors to save.
save v(g_19_2) v(g_19_4) i(v_s_16_2) i(v_s_11_0) v(g_19_1) i(v_s_14_2) v(g_17_4) v(g_10_0) i(v_s_10_2) v(g_14_2) v(g_12_1) v(g_11_3) i(v_s_12_0) v(g_15_1) i(v_s_13_1) i(v_s_18_0) i(v_s_15_3) v(g_13_4) i(v_s_11_3) v(g_10_2) i(v_s_10_4) i(v_s_18_1) i(v_s_16_4) v(g_16_4) v(g_12_3) v(g_14_1) i(v_s_15_2) i(v_s_12_1) v(g_16_0) v(g_16_1) i(v_s_13_2) v(g_18_2) v(g_13_1) i(v_s_16_3) i(v_s_19_4) i(v_s_14_4) v(g_17_0) i(v_s_16_1) i(v_s_10_1) v(g_11_1) i(v_s_17_3) v(g_11_4) i(v_s_15_0) v(g_15_2) v(g_10_3) i(v_s_15_4) i(v_s_16_0) i(v_s_18_2) i(v_s_12_3) i(v_s_19_3) v(g_18_0) v(g_15_0) i(v_s_10_3) i(v_s_19_1) v(g_10_1) v(g_12_0) v(g_14_3) v(g_15_3) v(g_16_2) v(g_17_2) i(v_s_18_4) i(v_s_13_0) v(g_10_4) i(v_s_12_2) v(g_11_2) v(g_16_3) v(g_17_1) v(g_12_2) v(g_12_4) v(g_13_0) i(v_s_12_4) i(v_s_19_0) i(v_s_14_1) v(g_13_3) i(v_s_13_3) i(v_s_17_4) i(v_s_11_2) v(g_13_2) v(g_17_3) i(v_s_17_2) v(g_19_0) v(g_19_3) i(v_s_10_0) v(g_15_4) v(g_14_0) i(v_s_11_1) v(g_18_4) v(g_14_4) i(v_s_18_3) i(v_s_15_1) i(v_s_13_4) i(v_s_14_0) i(v_s_17_1) i(v_s_17_0) v(g_18_1) i(v_s_11_4) v(g_11_0) v(g_18_3) i(v_s_19_2) i(v_s_14_3)

** Run the dc sweep analysis.
dc v_sweep -0.5 1.6 0.1

** Save the output to file.
set wr_vecnames
set wr_singlescale
wrdata /home/gazi/Desktop/Work/custom_packages/calibration/test/mosfet_level_1/results/calibration_2023-06-25_23:50:19/simulation_files/dc_sweep_7.csv v(g_19_2) v(g_19_4) i(v_s_16_2) i(v_s_11_0) v(g_19_1) i(v_s_14_2) v(g_17_4) v(g_10_0) i(v_s_10_2) v(g_14_2) v(g_12_1) v(g_11_3) i(v_s_12_0) v(g_15_1) i(v_s_13_1) i(v_s_18_0) i(v_s_15_3) v(g_13_4) i(v_s_11_3) v(g_10_2) i(v_s_10_4) i(v_s_18_1) i(v_s_16_4) v(g_16_4) v(g_12_3) v(g_14_1) i(v_s_15_2) i(v_s_12_1) v(g_16_0) v(g_16_1) i(v_s_13_2) v(g_18_2) v(g_13_1) i(v_s_16_3) i(v_s_19_4) i(v_s_14_4) v(g_17_0) i(v_s_16_1) i(v_s_10_1) v(g_11_1) i(v_s_17_3) v(g_11_4) i(v_s_15_0) v(g_15_2) v(g_10_3) i(v_s_15_4) i(v_s_16_0) i(v_s_18_2) i(v_s_12_3) i(v_s_19_3) v(g_18_0) v(g_15_0) i(v_s_10_3) i(v_s_19_1) v(g_10_1) v(g_12_0) v(g_14_3) v(g_15_3) v(g_16_2) v(g_17_2) i(v_s_18_4) i(v_s_13_0) v(g_10_4) i(v_s_12_2) v(g_11_2) v(g_16_3) v(g_17_1) v(g_12_2) v(g_12_4) v(g_13_0) i(v_s_12_4) i(v_s_19_0) i(v_s_14_1) v(g_13_3) i(v_s_13_3) i(v_s_17_4) i(v_s_11_2) v(g_13_2) v(g_17_3) i(v_s_17_2) v(g_19_0) v(g_19_3) i(v_s_10_0) v(g_15_4) v(g_14_0) i(v_s_11_1) v(g_18_4) v(g_14_4) i(v_s_18_3) i(v_s_15_1) i(v_s_13_4) i(v_s_14_0) i(v_s_17_1) i(v_s_17_0) v(g_18_1) i(v_s_11_4) v(g_11_0) v(g_18_3) i(v_s_19_2) i(v_s_14_3)

.endc
********** End of control section **********

.end
