**********************************************************
* THIS FILE IS GENERATED BY AIVALANCHE
* FILE ID: 6
* SIMULATION TYPE: dc_list
**********************************************************

* Define the temperature
.TEMP 25.0

* Include the dut file
.INCLUDE /home/gazi/Desktop/Work/custom_packages/calibration/src/templates/mosfet_level_1/nmos/dut.cir

** Start testbenches

********************* dut testbench 1_4 *********************
e_ds_1_4 d_1_4 0 v_sweep 0 1
v_gs_1_4 g_1_4 0 1.0
v_s_1_4 s_1_4 0 0
v_bs_1_4 b_1_4 0 0.0
x_1_4 d_1_4 g_1_4 s_1_4 b_1_4 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

** End testbenches

* Declare the v_sweep, which will change during the simulation.
v_sweep v_sweep 0 0

********** Start of control section **********
.control

** Model parameters start
alterparam dut vto = 0.6528133129632973
alterparam dut kp = 1.0509296938396604e-07
alterparam dut gamma = 0.1709614219110378
alterparam dut phi = 0.41029314207031514
alterparam dut rd = 0.13897906083831235
alterparam dut rs = 1.2825335980556474
alterparam dut cbd = 2.2256027644739702e-20
alterparam dut cbs = 2.2256027644739702e-20
alterparam dut is = 3.7981577206957224e-12
alterparam dut pb = 1.4840971917374743
alterparam dut cgso = 1.932718094724201e-13
alterparam dut cgdo = 4.7886694024182e-13
alterparam dut cgbo = 5.91568468822088e-12
alterparam dut rsh = 19.739065334704655
alterparam dut cj = 1.5986386488101735e-06
alterparam dut mj = 0.6483681844669367
alterparam dut cjsw = 1.8202599022008183e-10
alterparam dut mjsw = 0.16945999751740515
alterparam dut tox = 9.604031259492341e-08
alterparam dut nsub = 286164164023.5453
alterparam dut nss = 12622225810977.88
alterparam dut nfs = 495330.76652341784
alterparam dut tpg = 3.2041840057977633
alterparam dut xj = 1.1582291673215674e-06
alterparam dut ld = 4.9533076652341785e-15
alterparam dut uo = 223.66657787511002
alterparam dut vmax = 222.56027644739703
alterparam dut kf = 2.7958704813874247e-21
alterparam dut af = 0.9440972706293765
alterparam dut fc = 1.5916096877325492
reset
** Model parameters end

** Declare the vectors to save.
save v(d_1_4) i(v_s_1_4)

** Write the header of the results file.
echo "v(d_1_4),i(v_s_1_4)" > /home/gazi/Desktop/Work/custom_packages/calibration/test/mosfet_level_1/results/calibration_2023-06-25_23:45:05/simulation_files/dc_list_6.csv

** Start the simulation loop.
set values_list = ( 0.0 0.2 0.3 0.4 0.5 0.6 0.7 0.8 0.9 1.0 1.1 1.2 1.3 1.4 1.5 1.6 )
foreach val $values_list
    alter v_sweep $val
    op
    echo "$&v(d_1_4),$&i(v_s_1_4)" >> /home/gazi/Desktop/Work/custom_packages/calibration/test/mosfet_level_1/results/calibration_2023-06-25_23:45:05/simulation_files/dc_list_6.csv
end

.endc
********** End of control section **********

.end
