**********************************************************
* THIS FILE IS GENERATED BY AIVALANCHE
* FILE ID: 8
* SIMULATION TYPE: dc_sweep
**********************************************************

* Define the temperature
.TEMP 25.0

* Include the dut file
.INCLUDE /home/gazi/Desktop/Work/custom_packages/calibration/src/templates/mosfet_level_1/nmos/dut.cir

** Start testbenches

********************* dut testbench 0_0 *********************
e_ds_0_0 d_0_0 0 v_sweep 0 1
v_gs_0_0 g_0_0 0 0.2
v_s_0_0 s_0_0 0 0
v_bs_0_0 b_0_0 0 -1.0
x_0_0 d_0_0 g_0_0 s_0_0 b_0_0 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 0_1 *********************
e_ds_0_1 d_0_1 0 v_sweep 0 1
v_gs_0_1 g_0_1 0 0.4
v_s_0_1 s_0_1 0 0
v_bs_0_1 b_0_1 0 -1.0
x_0_1 d_0_1 g_0_1 s_0_1 b_0_1 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 0_2 *********************
e_ds_0_2 d_0_2 0 v_sweep 0 1
v_gs_0_2 g_0_2 0 0.6
v_s_0_2 s_0_2 0 0
v_bs_0_2 b_0_2 0 -1.0
x_0_2 d_0_2 g_0_2 s_0_2 b_0_2 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 0_3 *********************
e_ds_0_3 d_0_3 0 v_sweep 0 1
v_gs_0_3 g_0_3 0 0.8
v_s_0_3 s_0_3 0 0
v_bs_0_3 b_0_3 0 -1.0
x_0_3 d_0_3 g_0_3 s_0_3 b_0_3 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 0_4 *********************
e_ds_0_4 d_0_4 0 v_sweep 0 1
v_gs_0_4 g_0_4 0 1.0
v_s_0_4 s_0_4 0 0
v_bs_0_4 b_0_4 0 -1.0
x_0_4 d_0_4 g_0_4 s_0_4 b_0_4 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 0_5 *********************
e_ds_0_5 d_0_5 0 v_sweep 0 1
v_gs_0_5 g_0_5 0 1.2
v_s_0_5 s_0_5 0 0
v_bs_0_5 b_0_5 0 -1.0
x_0_5 d_0_5 g_0_5 s_0_5 b_0_5 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 0_6 *********************
e_ds_0_6 d_0_6 0 v_sweep 0 1
v_gs_0_6 g_0_6 0 1.4
v_s_0_6 s_0_6 0 0
v_bs_0_6 b_0_6 0 -1.0
x_0_6 d_0_6 g_0_6 s_0_6 b_0_6 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 0_7 *********************
e_ds_0_7 d_0_7 0 v_sweep 0 1
v_gs_0_7 g_0_7 0 1.6
v_s_0_7 s_0_7 0 0
v_bs_0_7 b_0_7 0 -1.0
x_0_7 d_0_7 g_0_7 s_0_7 b_0_7 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 1_0 *********************
e_ds_1_0 d_1_0 0 v_sweep 0 1
v_gs_1_0 g_1_0 0 0.2
v_s_1_0 s_1_0 0 0
v_bs_1_0 b_1_0 0 0.0
x_1_0 d_1_0 g_1_0 s_1_0 b_1_0 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 1_1 *********************
e_ds_1_1 d_1_1 0 v_sweep 0 1
v_gs_1_1 g_1_1 0 0.4
v_s_1_1 s_1_1 0 0
v_bs_1_1 b_1_1 0 0.0
x_1_1 d_1_1 g_1_1 s_1_1 b_1_1 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 1_2 *********************
e_ds_1_2 d_1_2 0 v_sweep 0 1
v_gs_1_2 g_1_2 0 0.6
v_s_1_2 s_1_2 0 0
v_bs_1_2 b_1_2 0 0.0
x_1_2 d_1_2 g_1_2 s_1_2 b_1_2 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 1_3 *********************
e_ds_1_3 d_1_3 0 v_sweep 0 1
v_gs_1_3 g_1_3 0 0.8
v_s_1_3 s_1_3 0 0
v_bs_1_3 b_1_3 0 0.0
x_1_3 d_1_3 g_1_3 s_1_3 b_1_3 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 1_5 *********************
e_ds_1_5 d_1_5 0 v_sweep 0 1
v_gs_1_5 g_1_5 0 1.2
v_s_1_5 s_1_5 0 0
v_bs_1_5 b_1_5 0 0.0
x_1_5 d_1_5 g_1_5 s_1_5 b_1_5 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 1_6 *********************
e_ds_1_6 d_1_6 0 v_sweep 0 1
v_gs_1_6 g_1_6 0 1.4
v_s_1_6 s_1_6 0 0
v_bs_1_6 b_1_6 0 0.0
x_1_6 d_1_6 g_1_6 s_1_6 b_1_6 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 1_7 *********************
e_ds_1_7 d_1_7 0 v_sweep 0 1
v_gs_1_7 g_1_7 0 1.6
v_s_1_7 s_1_7 0 0
v_bs_1_7 b_1_7 0 0.0
x_1_7 d_1_7 g_1_7 s_1_7 b_1_7 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 2_0 *********************
e_ds_2_0 d_2_0 0 v_sweep 0 1
v_gs_2_0 g_2_0 0 0.2
v_s_2_0 s_2_0 0 0
v_bs_2_0 b_2_0 0 -1.0
x_2_0 d_2_0 g_2_0 s_2_0 b_2_0 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 2_1 *********************
e_ds_2_1 d_2_1 0 v_sweep 0 1
v_gs_2_1 g_2_1 0 0.4
v_s_2_1 s_2_1 0 0
v_bs_2_1 b_2_1 0 -1.0
x_2_1 d_2_1 g_2_1 s_2_1 b_2_1 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 2_2 *********************
e_ds_2_2 d_2_2 0 v_sweep 0 1
v_gs_2_2 g_2_2 0 0.6
v_s_2_2 s_2_2 0 0
v_bs_2_2 b_2_2 0 -1.0
x_2_2 d_2_2 g_2_2 s_2_2 b_2_2 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 2_3 *********************
e_ds_2_3 d_2_3 0 v_sweep 0 1
v_gs_2_3 g_2_3 0 0.8
v_s_2_3 s_2_3 0 0
v_bs_2_3 b_2_3 0 -1.0
x_2_3 d_2_3 g_2_3 s_2_3 b_2_3 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 2_4 *********************
e_ds_2_4 d_2_4 0 v_sweep 0 1
v_gs_2_4 g_2_4 0 1.0
v_s_2_4 s_2_4 0 0
v_bs_2_4 b_2_4 0 -1.0
x_2_4 d_2_4 g_2_4 s_2_4 b_2_4 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 2_5 *********************
e_ds_2_5 d_2_5 0 v_sweep 0 1
v_gs_2_5 g_2_5 0 1.2
v_s_2_5 s_2_5 0 0
v_bs_2_5 b_2_5 0 -1.0
x_2_5 d_2_5 g_2_5 s_2_5 b_2_5 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 2_6 *********************
e_ds_2_6 d_2_6 0 v_sweep 0 1
v_gs_2_6 g_2_6 0 1.4
v_s_2_6 s_2_6 0 0
v_bs_2_6 b_2_6 0 -1.0
x_2_6 d_2_6 g_2_6 s_2_6 b_2_6 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 2_7 *********************
e_ds_2_7 d_2_7 0 v_sweep 0 1
v_gs_2_7 g_2_7 0 1.6
v_s_2_7 s_2_7 0 0
v_bs_2_7 b_2_7 0 -1.0
x_2_7 d_2_7 g_2_7 s_2_7 b_2_7 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 3_0 *********************
e_ds_3_0 d_3_0 0 v_sweep 0 1
v_gs_3_0 g_3_0 0 0.2
v_s_3_0 s_3_0 0 0
v_bs_3_0 b_3_0 0 0.0
x_3_0 d_3_0 g_3_0 s_3_0 b_3_0 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 3_1 *********************
e_ds_3_1 d_3_1 0 v_sweep 0 1
v_gs_3_1 g_3_1 0 0.4
v_s_3_1 s_3_1 0 0
v_bs_3_1 b_3_1 0 0.0
x_3_1 d_3_1 g_3_1 s_3_1 b_3_1 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 3_2 *********************
e_ds_3_2 d_3_2 0 v_sweep 0 1
v_gs_3_2 g_3_2 0 0.6
v_s_3_2 s_3_2 0 0
v_bs_3_2 b_3_2 0 0.0
x_3_2 d_3_2 g_3_2 s_3_2 b_3_2 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 3_3 *********************
e_ds_3_3 d_3_3 0 v_sweep 0 1
v_gs_3_3 g_3_3 0 0.8
v_s_3_3 s_3_3 0 0
v_bs_3_3 b_3_3 0 0.0
x_3_3 d_3_3 g_3_3 s_3_3 b_3_3 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 3_4 *********************
e_ds_3_4 d_3_4 0 v_sweep 0 1
v_gs_3_4 g_3_4 0 1.0
v_s_3_4 s_3_4 0 0
v_bs_3_4 b_3_4 0 0.0
x_3_4 d_3_4 g_3_4 s_3_4 b_3_4 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 3_5 *********************
e_ds_3_5 d_3_5 0 v_sweep 0 1
v_gs_3_5 g_3_5 0 1.2
v_s_3_5 s_3_5 0 0
v_bs_3_5 b_3_5 0 0.0
x_3_5 d_3_5 g_3_5 s_3_5 b_3_5 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 3_6 *********************
e_ds_3_6 d_3_6 0 v_sweep 0 1
v_gs_3_6 g_3_6 0 1.4
v_s_3_6 s_3_6 0 0
v_bs_3_6 b_3_6 0 0.0
x_3_6 d_3_6 g_3_6 s_3_6 b_3_6 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 3_7 *********************
e_ds_3_7 d_3_7 0 v_sweep 0 1
v_gs_3_7 g_3_7 0 1.6
v_s_3_7 s_3_7 0 0
v_bs_3_7 b_3_7 0 0.0
x_3_7 d_3_7 g_3_7 s_3_7 b_3_7 dut w=5e-06 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 4_0 *********************
e_ds_4_0 d_4_0 0 v_sweep 0 1
v_gs_4_0 g_4_0 0 0.2
v_s_4_0 s_4_0 0 0
v_bs_4_0 b_4_0 0 -1.0
x_4_0 d_4_0 g_4_0 s_4_0 b_4_0 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 4_1 *********************
e_ds_4_1 d_4_1 0 v_sweep 0 1
v_gs_4_1 g_4_1 0 0.4
v_s_4_1 s_4_1 0 0
v_bs_4_1 b_4_1 0 -1.0
x_4_1 d_4_1 g_4_1 s_4_1 b_4_1 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 4_2 *********************
e_ds_4_2 d_4_2 0 v_sweep 0 1
v_gs_4_2 g_4_2 0 0.6
v_s_4_2 s_4_2 0 0
v_bs_4_2 b_4_2 0 -1.0
x_4_2 d_4_2 g_4_2 s_4_2 b_4_2 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 4_3 *********************
e_ds_4_3 d_4_3 0 v_sweep 0 1
v_gs_4_3 g_4_3 0 0.8
v_s_4_3 s_4_3 0 0
v_bs_4_3 b_4_3 0 -1.0
x_4_3 d_4_3 g_4_3 s_4_3 b_4_3 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 4_4 *********************
e_ds_4_4 d_4_4 0 v_sweep 0 1
v_gs_4_4 g_4_4 0 1.0
v_s_4_4 s_4_4 0 0
v_bs_4_4 b_4_4 0 -1.0
x_4_4 d_4_4 g_4_4 s_4_4 b_4_4 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 4_5 *********************
e_ds_4_5 d_4_5 0 v_sweep 0 1
v_gs_4_5 g_4_5 0 1.2
v_s_4_5 s_4_5 0 0
v_bs_4_5 b_4_5 0 -1.0
x_4_5 d_4_5 g_4_5 s_4_5 b_4_5 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 4_6 *********************
e_ds_4_6 d_4_6 0 v_sweep 0 1
v_gs_4_6 g_4_6 0 1.4
v_s_4_6 s_4_6 0 0
v_bs_4_6 b_4_6 0 -1.0
x_4_6 d_4_6 g_4_6 s_4_6 b_4_6 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 4_7 *********************
e_ds_4_7 d_4_7 0 v_sweep 0 1
v_gs_4_7 g_4_7 0 1.6
v_s_4_7 s_4_7 0 0
v_bs_4_7 b_4_7 0 -1.0
x_4_7 d_4_7 g_4_7 s_4_7 b_4_7 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 5_0 *********************
e_ds_5_0 d_5_0 0 v_sweep 0 1
v_gs_5_0 g_5_0 0 0.2
v_s_5_0 s_5_0 0 0
v_bs_5_0 b_5_0 0 0.0
x_5_0 d_5_0 g_5_0 s_5_0 b_5_0 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 5_1 *********************
e_ds_5_1 d_5_1 0 v_sweep 0 1
v_gs_5_1 g_5_1 0 0.4
v_s_5_1 s_5_1 0 0
v_bs_5_1 b_5_1 0 0.0
x_5_1 d_5_1 g_5_1 s_5_1 b_5_1 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 5_2 *********************
e_ds_5_2 d_5_2 0 v_sweep 0 1
v_gs_5_2 g_5_2 0 0.6
v_s_5_2 s_5_2 0 0
v_bs_5_2 b_5_2 0 0.0
x_5_2 d_5_2 g_5_2 s_5_2 b_5_2 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 5_3 *********************
e_ds_5_3 d_5_3 0 v_sweep 0 1
v_gs_5_3 g_5_3 0 0.8
v_s_5_3 s_5_3 0 0
v_bs_5_3 b_5_3 0 0.0
x_5_3 d_5_3 g_5_3 s_5_3 b_5_3 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 5_4 *********************
e_ds_5_4 d_5_4 0 v_sweep 0 1
v_gs_5_4 g_5_4 0 1.0
v_s_5_4 s_5_4 0 0
v_bs_5_4 b_5_4 0 0.0
x_5_4 d_5_4 g_5_4 s_5_4 b_5_4 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 5_5 *********************
e_ds_5_5 d_5_5 0 v_sweep 0 1
v_gs_5_5 g_5_5 0 1.2
v_s_5_5 s_5_5 0 0
v_bs_5_5 b_5_5 0 0.0
x_5_5 d_5_5 g_5_5 s_5_5 b_5_5 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 5_6 *********************
e_ds_5_6 d_5_6 0 v_sweep 0 1
v_gs_5_6 g_5_6 0 1.4
v_s_5_6 s_5_6 0 0
v_bs_5_6 b_5_6 0 0.0
x_5_6 d_5_6 g_5_6 s_5_6 b_5_6 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 5_7 *********************
e_ds_5_7 d_5_7 0 v_sweep 0 1
v_gs_5_7 g_5_7 0 1.6
v_s_5_7 s_5_7 0 0
v_bs_5_7 b_5_7 0 0.0
x_5_7 d_5_7 g_5_7 s_5_7 b_5_7 dut w=1e-06 l=1e-06 m=1.0
*************************************************************

********************* dut testbench 6_0 *********************
e_ds_6_0 d_6_0 0 v_sweep 0 1
v_gs_6_0 g_6_0 0 0.2
v_s_6_0 s_6_0 0 0
v_bs_6_0 b_6_0 0 -1.0
x_6_0 d_6_0 g_6_0 s_6_0 b_6_0 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 6_1 *********************
e_ds_6_1 d_6_1 0 v_sweep 0 1
v_gs_6_1 g_6_1 0 0.4
v_s_6_1 s_6_1 0 0
v_bs_6_1 b_6_1 0 -1.0
x_6_1 d_6_1 g_6_1 s_6_1 b_6_1 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 6_2 *********************
e_ds_6_2 d_6_2 0 v_sweep 0 1
v_gs_6_2 g_6_2 0 0.6
v_s_6_2 s_6_2 0 0
v_bs_6_2 b_6_2 0 -1.0
x_6_2 d_6_2 g_6_2 s_6_2 b_6_2 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 6_3 *********************
e_ds_6_3 d_6_3 0 v_sweep 0 1
v_gs_6_3 g_6_3 0 0.8
v_s_6_3 s_6_3 0 0
v_bs_6_3 b_6_3 0 -1.0
x_6_3 d_6_3 g_6_3 s_6_3 b_6_3 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 6_4 *********************
e_ds_6_4 d_6_4 0 v_sweep 0 1
v_gs_6_4 g_6_4 0 1.0
v_s_6_4 s_6_4 0 0
v_bs_6_4 b_6_4 0 -1.0
x_6_4 d_6_4 g_6_4 s_6_4 b_6_4 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 6_5 *********************
e_ds_6_5 d_6_5 0 v_sweep 0 1
v_gs_6_5 g_6_5 0 1.2
v_s_6_5 s_6_5 0 0
v_bs_6_5 b_6_5 0 -1.0
x_6_5 d_6_5 g_6_5 s_6_5 b_6_5 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 6_6 *********************
e_ds_6_6 d_6_6 0 v_sweep 0 1
v_gs_6_6 g_6_6 0 1.4
v_s_6_6 s_6_6 0 0
v_bs_6_6 b_6_6 0 -1.0
x_6_6 d_6_6 g_6_6 s_6_6 b_6_6 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 6_7 *********************
e_ds_6_7 d_6_7 0 v_sweep 0 1
v_gs_6_7 g_6_7 0 1.6
v_s_6_7 s_6_7 0 0
v_bs_6_7 b_6_7 0 -1.0
x_6_7 d_6_7 g_6_7 s_6_7 b_6_7 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 7_0 *********************
e_ds_7_0 d_7_0 0 v_sweep 0 1
v_gs_7_0 g_7_0 0 0.2
v_s_7_0 s_7_0 0 0
v_bs_7_0 b_7_0 0 0.0
x_7_0 d_7_0 g_7_0 s_7_0 b_7_0 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 7_1 *********************
e_ds_7_1 d_7_1 0 v_sweep 0 1
v_gs_7_1 g_7_1 0 0.4
v_s_7_1 s_7_1 0 0
v_bs_7_1 b_7_1 0 0.0
x_7_1 d_7_1 g_7_1 s_7_1 b_7_1 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 7_2 *********************
e_ds_7_2 d_7_2 0 v_sweep 0 1
v_gs_7_2 g_7_2 0 0.6
v_s_7_2 s_7_2 0 0
v_bs_7_2 b_7_2 0 0.0
x_7_2 d_7_2 g_7_2 s_7_2 b_7_2 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 7_3 *********************
e_ds_7_3 d_7_3 0 v_sweep 0 1
v_gs_7_3 g_7_3 0 0.8
v_s_7_3 s_7_3 0 0
v_bs_7_3 b_7_3 0 0.0
x_7_3 d_7_3 g_7_3 s_7_3 b_7_3 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 7_4 *********************
e_ds_7_4 d_7_4 0 v_sweep 0 1
v_gs_7_4 g_7_4 0 1.0
v_s_7_4 s_7_4 0 0
v_bs_7_4 b_7_4 0 0.0
x_7_4 d_7_4 g_7_4 s_7_4 b_7_4 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 7_5 *********************
e_ds_7_5 d_7_5 0 v_sweep 0 1
v_gs_7_5 g_7_5 0 1.2
v_s_7_5 s_7_5 0 0
v_bs_7_5 b_7_5 0 0.0
x_7_5 d_7_5 g_7_5 s_7_5 b_7_5 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 7_6 *********************
e_ds_7_6 d_7_6 0 v_sweep 0 1
v_gs_7_6 g_7_6 0 1.4
v_s_7_6 s_7_6 0 0
v_bs_7_6 b_7_6 0 0.0
x_7_6 d_7_6 g_7_6 s_7_6 b_7_6 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 7_7 *********************
e_ds_7_7 d_7_7 0 v_sweep 0 1
v_gs_7_7 g_7_7 0 1.6
v_s_7_7 s_7_7 0 0
v_bs_7_7 b_7_7 0 0.0
x_7_7 d_7_7 g_7_7 s_7_7 b_7_7 dut w=1e-05 l=5e-06 m=1.0
*************************************************************

********************* dut testbench 8_0 *********************
e_ds_8_0 d_8_0 0 v_sweep 0 1
v_gs_8_0 g_8_0 0 0.2
v_s_8_0 s_8_0 0 0
v_bs_8_0 b_8_0 0 -1.0
x_8_0 d_8_0 g_8_0 s_8_0 b_8_0 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 8_1 *********************
e_ds_8_1 d_8_1 0 v_sweep 0 1
v_gs_8_1 g_8_1 0 0.4
v_s_8_1 s_8_1 0 0
v_bs_8_1 b_8_1 0 -1.0
x_8_1 d_8_1 g_8_1 s_8_1 b_8_1 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 8_2 *********************
e_ds_8_2 d_8_2 0 v_sweep 0 1
v_gs_8_2 g_8_2 0 0.6
v_s_8_2 s_8_2 0 0
v_bs_8_2 b_8_2 0 -1.0
x_8_2 d_8_2 g_8_2 s_8_2 b_8_2 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 8_3 *********************
e_ds_8_3 d_8_3 0 v_sweep 0 1
v_gs_8_3 g_8_3 0 0.8
v_s_8_3 s_8_3 0 0
v_bs_8_3 b_8_3 0 -1.0
x_8_3 d_8_3 g_8_3 s_8_3 b_8_3 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 8_4 *********************
e_ds_8_4 d_8_4 0 v_sweep 0 1
v_gs_8_4 g_8_4 0 1.0
v_s_8_4 s_8_4 0 0
v_bs_8_4 b_8_4 0 -1.0
x_8_4 d_8_4 g_8_4 s_8_4 b_8_4 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 8_5 *********************
e_ds_8_5 d_8_5 0 v_sweep 0 1
v_gs_8_5 g_8_5 0 1.2
v_s_8_5 s_8_5 0 0
v_bs_8_5 b_8_5 0 -1.0
x_8_5 d_8_5 g_8_5 s_8_5 b_8_5 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 8_6 *********************
e_ds_8_6 d_8_6 0 v_sweep 0 1
v_gs_8_6 g_8_6 0 1.4
v_s_8_6 s_8_6 0 0
v_bs_8_6 b_8_6 0 -1.0
x_8_6 d_8_6 g_8_6 s_8_6 b_8_6 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 8_7 *********************
e_ds_8_7 d_8_7 0 v_sweep 0 1
v_gs_8_7 g_8_7 0 1.6
v_s_8_7 s_8_7 0 0
v_bs_8_7 b_8_7 0 -1.0
x_8_7 d_8_7 g_8_7 s_8_7 b_8_7 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 9_0 *********************
e_ds_9_0 d_9_0 0 v_sweep 0 1
v_gs_9_0 g_9_0 0 0.2
v_s_9_0 s_9_0 0 0
v_bs_9_0 b_9_0 0 0.0
x_9_0 d_9_0 g_9_0 s_9_0 b_9_0 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 9_1 *********************
e_ds_9_1 d_9_1 0 v_sweep 0 1
v_gs_9_1 g_9_1 0 0.4
v_s_9_1 s_9_1 0 0
v_bs_9_1 b_9_1 0 0.0
x_9_1 d_9_1 g_9_1 s_9_1 b_9_1 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 9_2 *********************
e_ds_9_2 d_9_2 0 v_sweep 0 1
v_gs_9_2 g_9_2 0 0.6
v_s_9_2 s_9_2 0 0
v_bs_9_2 b_9_2 0 0.0
x_9_2 d_9_2 g_9_2 s_9_2 b_9_2 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 9_3 *********************
e_ds_9_3 d_9_3 0 v_sweep 0 1
v_gs_9_3 g_9_3 0 0.8
v_s_9_3 s_9_3 0 0
v_bs_9_3 b_9_3 0 0.0
x_9_3 d_9_3 g_9_3 s_9_3 b_9_3 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 9_4 *********************
e_ds_9_4 d_9_4 0 v_sweep 0 1
v_gs_9_4 g_9_4 0 1.0
v_s_9_4 s_9_4 0 0
v_bs_9_4 b_9_4 0 0.0
x_9_4 d_9_4 g_9_4 s_9_4 b_9_4 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 9_5 *********************
e_ds_9_5 d_9_5 0 v_sweep 0 1
v_gs_9_5 g_9_5 0 1.2
v_s_9_5 s_9_5 0 0
v_bs_9_5 b_9_5 0 0.0
x_9_5 d_9_5 g_9_5 s_9_5 b_9_5 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 9_6 *********************
e_ds_9_6 d_9_6 0 v_sweep 0 1
v_gs_9_6 g_9_6 0 1.4
v_s_9_6 s_9_6 0 0
v_bs_9_6 b_9_6 0 0.0
x_9_6 d_9_6 g_9_6 s_9_6 b_9_6 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

********************* dut testbench 9_7 *********************
e_ds_9_7 d_9_7 0 v_sweep 0 1
v_gs_9_7 g_9_7 0 1.6
v_s_9_7 s_9_7 0 0
v_bs_9_7 b_9_7 0 0.0
x_9_7 d_9_7 g_9_7 s_9_7 b_9_7 dut w=5e-06 l=1e-05 m=1.0
*************************************************************

** End testbenches

* Declare the v_sweep, which will change during the simulation.
v_sweep v_sweep 0 0

********** Start of control section **********
.control

** Model parameters start
alterparam dut vto = 0.32719296983015134
alterparam dut kp = 2.0388900190589346e-05
alterparam dut gamma = 0.10316177751116831
alterparam dut phi = 0.8418301600562597
alterparam dut rd = 1.7977356919308394
alterparam dut rs = 1.600721106386587
alterparam dut cbd = 3.060557865643783e-16
alterparam dut cbs = 1.1098902963629738e-19
alterparam dut is = 6.173293136174817e-16
alterparam dut pb = 0.4123549922202785
alterparam dut cgso = 8.329601769822691e-11
alterparam dut cgdo = 1.2699452166256085e-13
alterparam dut cgbo = 1.1974504120501866e-16
alterparam dut rsh = 6.215052824858792
alterparam dut cj = 1.1695349558355424e-10
alterparam dut mj = 0.06553871612905432
alterparam dut cjsw = 3.411780558273831e-10
alterparam dut mjsw = 0.5509845322943423
alterparam dut tox = 1.1798379320737952e-07
alterparam dut nsub = 9.367014448954028e+18
alterparam dut nss = 3822467733052.639
alterparam dut nfs = 1982125934627.9956
alterparam dut tpg = 1.1422261094934048
alterparam dut xj = 9.367014448954027e-07
alterparam dut ld = 9.367014448954027e-07
alterparam dut uo = 847.4576568723296
alterparam dut vmax = 305863.53164571506
alterparam dut kf = 9.367014448954027e-22
alterparam dut af = 0.5182560313927939
alterparam dut fc = 3.2436362742859175
reset
** Model parameters end

** Declare the vectors to save.
save v(d_7_1) i(v_s_7_6) i(v_s_9_2) v(d_5_6) i(v_s_6_3) i(v_s_2_1) i(v_s_3_6) i(v_s_4_1) v(d_8_0) v(d_1_6) i(v_s_2_4) v(d_3_5) i(v_s_0_7) v(d_4_1) v(d_0_5) v(d_1_1) i(v_s_1_7) i(v_s_0_4) v(d_4_2) i(v_s_0_3) i(v_s_0_1) v(d_3_0) v(d_1_7) i(v_s_9_1) v(d_5_7) i(v_s_0_0) v(d_3_6) i(v_s_2_5) v(d_9_5) v(d_0_2) i(v_s_2_7) v(d_5_5) i(v_s_6_5) v(d_9_2) i(v_s_0_5) v(d_9_4) i(v_s_6_0) v(d_5_4) v(d_9_6) i(v_s_5_3) v(d_3_7) v(d_5_0) v(d_1_2) i(v_s_3_7) v(d_2_0) i(v_s_5_7) i(v_s_3_5) v(d_6_6) i(v_s_4_7) i(v_s_0_6) v(d_6_1) v(d_7_2) i(v_s_8_5) i(v_s_2_2) i(v_s_9_5) i(v_s_6_2) i(v_s_8_1) i(v_s_2_6) i(v_s_4_6) v(d_9_1) v(d_5_2) i(v_s_7_0) i(v_s_5_5) i(v_s_7_5) v(d_7_3) v(d_6_7) v(d_8_4) v(d_7_7) v(d_9_7) v(d_0_7) i(v_s_2_3) i(v_s_3_1) v(d_2_7) v(d_6_2) i(v_s_5_1) v(d_8_5) v(d_2_6) i(v_s_1_0) i(v_s_8_2) v(d_3_2) v(d_8_6) v(d_0_1) i(v_s_4_0) i(v_s_1_6) i(v_s_7_7) v(d_4_3) v(d_8_1) v(d_9_3) i(v_s_6_7) v(d_5_3) i(v_s_4_2) v(d_3_1) i(v_s_3_3) i(v_s_6_4) i(v_s_9_4) v(d_2_5) v(d_3_4) v(d_0_6) v(d_7_6) v(d_8_7) i(v_s_6_6) i(v_s_9_6) v(d_3_3) v(d_4_4) v(d_7_5) v(d_9_0) i(v_s_1_5) i(v_s_7_4) v(d_8_2) i(v_s_1_1) i(v_s_7_1) i(v_s_8_7) i(v_s_8_0) i(v_s_4_4) v(d_0_3) v(d_0_0) i(v_s_1_3) v(d_2_4) i(v_s_8_3) i(v_s_9_7) i(v_s_5_2) v(d_5_1) v(d_8_3) v(d_2_2) v(d_0_4) i(v_s_5_0) v(d_7_0) i(v_s_8_4) i(v_s_8_6) v(d_1_5) v(d_2_1) v(d_6_5) i(v_s_7_2) i(v_s_3_4) i(v_s_9_0) i(v_s_3_2) i(v_s_2_0) i(v_s_0_2) v(d_1_0) v(d_2_3) v(d_4_6) v(d_6_3) v(d_7_4) i(v_s_7_3) i(v_s_5_6) i(v_s_6_1) v(d_1_3) i(v_s_3_0) i(v_s_1_2) v(d_4_7) i(v_s_9_3) i(v_s_5_4) v(d_6_4) v(d_4_0) v(d_6_0) i(v_s_4_3) v(d_4_5) i(v_s_4_5)

** Run the dc sweep analysis.
dc v_sweep 0.0 1.6 0.1

** Save the output to file.
set wr_vecnames
set wr_singlescale
wrdata /home/gazi/Desktop/Work/custom_packages/calibration/test/mosfet_level_1/results/calibration_2023-06-25_23:38:00/simulation_files/dc_sweep_8.csv v(d_7_1) i(v_s_7_6) i(v_s_9_2) v(d_5_6) i(v_s_6_3) i(v_s_2_1) i(v_s_3_6) i(v_s_4_1) v(d_8_0) v(d_1_6) i(v_s_2_4) v(d_3_5) i(v_s_0_7) v(d_4_1) v(d_0_5) v(d_1_1) i(v_s_1_7) i(v_s_0_4) v(d_4_2) i(v_s_0_3) i(v_s_0_1) v(d_3_0) v(d_1_7) i(v_s_9_1) v(d_5_7) i(v_s_0_0) v(d_3_6) i(v_s_2_5) v(d_9_5) v(d_0_2) i(v_s_2_7) v(d_5_5) i(v_s_6_5) v(d_9_2) i(v_s_0_5) v(d_9_4) i(v_s_6_0) v(d_5_4) v(d_9_6) i(v_s_5_3) v(d_3_7) v(d_5_0) v(d_1_2) i(v_s_3_7) v(d_2_0) i(v_s_5_7) i(v_s_3_5) v(d_6_6) i(v_s_4_7) i(v_s_0_6) v(d_6_1) v(d_7_2) i(v_s_8_5) i(v_s_2_2) i(v_s_9_5) i(v_s_6_2) i(v_s_8_1) i(v_s_2_6) i(v_s_4_6) v(d_9_1) v(d_5_2) i(v_s_7_0) i(v_s_5_5) i(v_s_7_5) v(d_7_3) v(d_6_7) v(d_8_4) v(d_7_7) v(d_9_7) v(d_0_7) i(v_s_2_3) i(v_s_3_1) v(d_2_7) v(d_6_2) i(v_s_5_1) v(d_8_5) v(d_2_6) i(v_s_1_0) i(v_s_8_2) v(d_3_2) v(d_8_6) v(d_0_1) i(v_s_4_0) i(v_s_1_6) i(v_s_7_7) v(d_4_3) v(d_8_1) v(d_9_3) i(v_s_6_7) v(d_5_3) i(v_s_4_2) v(d_3_1) i(v_s_3_3) i(v_s_6_4) i(v_s_9_4) v(d_2_5) v(d_3_4) v(d_0_6) v(d_7_6) v(d_8_7) i(v_s_6_6) i(v_s_9_6) v(d_3_3) v(d_4_4) v(d_7_5) v(d_9_0) i(v_s_1_5) i(v_s_7_4) v(d_8_2) i(v_s_1_1) i(v_s_7_1) i(v_s_8_7) i(v_s_8_0) i(v_s_4_4) v(d_0_3) v(d_0_0) i(v_s_1_3) v(d_2_4) i(v_s_8_3) i(v_s_9_7) i(v_s_5_2) v(d_5_1) v(d_8_3) v(d_2_2) v(d_0_4) i(v_s_5_0) v(d_7_0) i(v_s_8_4) i(v_s_8_6) v(d_1_5) v(d_2_1) v(d_6_5) i(v_s_7_2) i(v_s_3_4) i(v_s_9_0) i(v_s_3_2) i(v_s_2_0) i(v_s_0_2) v(d_1_0) v(d_2_3) v(d_4_6) v(d_6_3) v(d_7_4) i(v_s_7_3) i(v_s_5_6) i(v_s_6_1) v(d_1_3) i(v_s_3_0) i(v_s_1_2) v(d_4_7) i(v_s_9_3) i(v_s_5_4) v(d_6_4) v(d_4_0) v(d_6_0) i(v_s_4_3) v(d_4_5) i(v_s_4_5)

.endc
********** End of control section **********

.end
