**********************************************************
* THIS FILE IS GENERATED BY AIVALANCHE
* FILE ID: 6
* SIMULATION TYPE: dc_list
**********************************************************

* Define the temperature
.TEMP 25.0

* Include the dut file
.INCLUDE /home/gazi/Desktop/Work/custom_packages/calibration/src/templates/mosfet_level_1/nmos/dut.cir

** Start testbenches

********************* dut testbench 1_4 *********************
e_ds_1_4 d_1_4 0 v_sweep 0 1
v_gs_1_4 g_1_4 0 1.0
v_s_1_4 s_1_4 0 0
v_bs_1_4 b_1_4 0 0.0
x_1_4 d_1_4 g_1_4 s_1_4 b_1_4 dut w=1e-05 l=1e-05 m=1.0
*************************************************************

** End testbenches

* Declare the v_sweep, which will change during the simulation.
v_sweep v_sweep 0 0

********** Start of control section **********
.control

** Model parameters start
alterparam dut vto = 0.32719296983015134
alterparam dut kp = 2.0388900190589346e-05
alterparam dut gamma = 0.10316177751116831
alterparam dut phi = 0.8418301600562597
alterparam dut rd = 1.7977356919308394
alterparam dut rs = 1.600721106386587
alterparam dut cbd = 3.060557865643783e-16
alterparam dut cbs = 1.1098902963629738e-19
alterparam dut is = 6.173293136174817e-16
alterparam dut pb = 0.4123549922202785
alterparam dut cgso = 8.329601769822691e-11
alterparam dut cgdo = 1.2699452166256085e-13
alterparam dut cgbo = 1.1974504120501866e-16
alterparam dut rsh = 6.215052824858792
alterparam dut cj = 1.1695349558355424e-10
alterparam dut mj = 0.06553871612905432
alterparam dut cjsw = 3.411780558273831e-10
alterparam dut mjsw = 0.5509845322943423
alterparam dut tox = 1.1798379320737952e-07
alterparam dut nsub = 9.367014448954028e+18
alterparam dut nss = 3822467733052.639
alterparam dut nfs = 1982125934627.9956
alterparam dut tpg = 1.1422261094934048
alterparam dut xj = 9.367014448954027e-07
alterparam dut ld = 9.367014448954027e-07
alterparam dut uo = 847.4576568723296
alterparam dut vmax = 305863.53164571506
alterparam dut kf = 9.367014448954027e-22
alterparam dut af = 0.5182560313927939
alterparam dut fc = 3.2436362742859175
reset
** Model parameters end

** Declare the vectors to save.
save i(v_s_1_4) v(d_1_4)

** Write the header of the results file.
echo "i(v_s_1_4),v(d_1_4)" > /home/gazi/Desktop/Work/custom_packages/calibration/test/mosfet_level_1/results/calibration_2023-06-25_23:38:00/simulation_files/dc_list_6.csv

** Start the simulation loop.
set values_list = ( 0.0 0.2 0.3 0.4 0.5 0.6 0.7 0.8 0.9 1.0 1.1 1.2 1.3 1.4 1.5 1.6 )
foreach val $values_list
    alter v_sweep $val
    op
    echo "$&i(v_s_1_4),$&v(d_1_4)" >> /home/gazi/Desktop/Work/custom_packages/calibration/test/mosfet_level_1/results/calibration_2023-06-25_23:38:00/simulation_files/dc_list_6.csv
end

.endc
********** End of control section **********

.end
