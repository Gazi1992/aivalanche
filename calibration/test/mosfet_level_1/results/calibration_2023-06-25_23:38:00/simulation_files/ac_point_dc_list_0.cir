**********************************************************
* THIS FILE IS GENERATED BY AIVALANCHE
* FILE ID: 0
* SIMULATION TYPE: ac_point_dc_list
**********************************************************

* Define the temperature
.TEMP 25.0

* Include the dut file
.INCLUDE /home/gazi/Desktop/Work/custom_packages/calibration/src/templates/mosfet_level_1/nmos/dut.cir

** Start testbenches

********************* dut testbench 21_1 *********************
v_gs_ac_21_1 g_21_1 g_ac_21_1 DC 0 AC 1
e_gs_21_1 g_ac_21_1 0 v_sweep 0 1
v_ds_21_1 d_21_1 0 0.0
v_s_21_1 s_21_1 0 0
v_bs_21_1 b_21_1 0 1.0
x_21_1 d_21_1 g_21_1 s_21_1 b_21_1 dut w=5e-06 l=6e-06 m=1.0
*************************************************************

** End testbenches

* Declare the v_sweep, which will change during the simulation.
v_sweep v_sweep 0 0

********** Start of control section **********
.control

** Model parameters start
alterparam dut vto = 0.32719296983015134
alterparam dut kp = 2.0388900190589346e-05
alterparam dut gamma = 0.10316177751116831
alterparam dut phi = 0.8418301600562597
alterparam dut rd = 1.7977356919308394
alterparam dut rs = 1.600721106386587
alterparam dut cbd = 3.060557865643783e-16
alterparam dut cbs = 1.1098902963629738e-19
alterparam dut is = 6.173293136174817e-16
alterparam dut pb = 0.4123549922202785
alterparam dut cgso = 8.329601769822691e-11
alterparam dut cgdo = 1.2699452166256085e-13
alterparam dut cgbo = 1.1974504120501866e-16
alterparam dut rsh = 6.215052824858792
alterparam dut cj = 1.1695349558355424e-10
alterparam dut mj = 0.06553871612905432
alterparam dut cjsw = 3.411780558273831e-10
alterparam dut mjsw = 0.5509845322943423
alterparam dut tox = 1.1798379320737952e-07
alterparam dut nsub = 9.367014448954028e+18
alterparam dut nss = 3822467733052.639
alterparam dut nfs = 1982125934627.9956
alterparam dut tpg = 1.1422261094934048
alterparam dut xj = 9.367014448954027e-07
alterparam dut ld = 9.367014448954027e-07
alterparam dut uo = 847.4576568723296
alterparam dut vmax = 305863.53164571506
alterparam dut kf = 9.367014448954027e-22
alterparam dut af = 0.5182560313927939
alterparam dut fc = 3.2436362742859175
reset
** Model parameters end

** Declare the vectors to save.
save i(v_s_21_1)

** Write the header of the results file.
echo "vgs,cgs_21_1" > /home/gazi/Desktop/Work/custom_packages/calibration/test/mosfet_level_1/results/calibration_2023-06-25_23:38:00/simulation_files/ac_point_dc_list_0.csv

** Start the simulation loop.
set values_list = ( -2.0 -1.95 -1.8 -1.75 -1.7 -1.65 -1.6 -1.55 -1.5 -1.45 -1.4 -1.35 -1.3 -1.25 -1.2 -1.15 -1.1 -1.05 -1.0 -0.95 -0.9 -0.85 -0.8 -0.75 -0.7 -0.65 -0.6 -0.55 -0.5 -0.45 -0.4 -0.35 -0.3 -0.25 -0.2 -0.15 -0.1 -0.05 1.20737e-15 0.05 0.1 0.15 0.2 0.25 0.3 0.35 0.4 0.45 0.5 0.55 0.6 0.65 0.7 0.75 0.8 0.85 0.9 0.95 1.0 1.05 1.1 1.15 1.2 1.25 1.3 1.35 1.4 1.45 1.5 1.55 1.6 1.65 1.7 1.75 1.8 1.85 1.9 1.95 2.0 )
foreach val $values_list
    alter v_sweep $val
    ac lin 1 10000.0 10000.0

    let cgs_21_1 = abs(imag(i(v_s_21_1)))/2*pi*10000.0

    echo "$val,$&cgs_21_1" >> /home/gazi/Desktop/Work/custom_packages/calibration/test/mosfet_level_1/results/calibration_2023-06-25_23:38:00/simulation_files/ac_point_dc_list_0.csv
end

.endc
********** End of control section **********

.end
