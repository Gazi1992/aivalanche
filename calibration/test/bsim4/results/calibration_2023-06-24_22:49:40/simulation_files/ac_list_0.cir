**********************************************************
* THIS FILE IS GENERATED BY AIVALANCHE
* FILE ID: 0
* SIMULATION TYPE: ac_list
**********************************************************

* Define the temperature
.TEMP 25.0

* Include the dut file
.INCLUDE /home/gazi/Desktop/Work/custom_packages/calibration/src/templates/bsim4/nmos/dut.cir

** Start testbenches

********************* dut testbench 21_1 *********************
v_gs_ac_21_1 g_21_1 g_ac_21_1 DC 0 AC 1
e_gs_21_1 g_ac_21_1 0 v_sweep 0 1
v_ds_21_1 d_21_1 0 0.0
v_s_21_1 s_21_1 0 0
v_bs_21_1 b_21_1 0 1.0
x_21_1 d_21_1 g_21_1 s_21_1 b_21_1 dut w=5e-06 l=6e-06 m=1.0
*************************************************************

** End testbenches

* Declare the v_sweep, which will change during the simulation.
v_sweep v_sweep 0 0

********** Start of control section **********
.control

** Model parameters start
alterparam dut a0 = 1.2829802535302375
alterparam dut a1 = 0.05402126553923373
alterparam dut a2 = 0.012602953682840923
alterparam dut acde = 1.032169399950194
alterparam dut ags = 0.004677170283231254
alterparam dut cf = 6.366874078905998e-13
alterparam dut cgdl = 9.874558105366722e-11
alterparam dut cgdo = 1.0006042419793892e-10
alterparam dut ckappas = 0.5932941415352184
alterparam dut clc = 8.232072481753776e-08
alterparam dut cle = 0.6358500400880214
alterparam dut dlc = 1*-6.55017324880909e-08
alterparam dut drout = 1.505090465253388
alterparam dut dsub = 0.18591348016839282
alterparam dut dvt0 = 4.241371249839157
alterparam dut dvt0w = 5.7714257194341965
alterparam dut dvt1 = 0.7623664638289739
alterparam dut dvt1w = 8407.623404961723
alterparam dut dvt2 = 0.043711698738005594
alterparam dut dvt2w = 1*-0.019220792184390018
alterparam dut dwg = 7.047796097954477e-08
alterparam dut eta0 = 0.6556210204969639
alterparam dut etab = 1*-0.053300115262231995
alterparam dut k1 = 0.5112410416048583
alterparam dut k2 = 1*-0.009344300254709961
alterparam dut k3 = 46.14382991603375
alterparam dut k3b = 1*-4.986266187290873
alterparam dut keta = 1*-0.0021625221455236904
alterparam dut lint = 1*-1.0864957206502068e-08
alterparam dut ll = 7.643962409501946e-14
alterparam dut moin = 14.106314089168016
alterparam dut ndep = 1.3984245596798648e+17
alterparam dut nfactor = 0.8322835532860009
alterparam dut ngate = 9.646612699988428e+19
alterparam dut noff = 0.9901689419112215
alterparam dut pclm = 1.2021589444674608e-06
alterparam dut pdiblc1 = 5.787505078332663e-06
alterparam dut pdiblc2 = 0.09746477335976629
alterparam dut pdiblcb = 1*-0.013951778270698156
alterparam dut pvag = 1*-0.6575805446127081
alterparam dut rdsw = 946.1889360453606
alterparam dut toxp = 5.082184281324919e-09
alterparam dut u0 = 41.60238575241454
alterparam dut ua = 1*-9.200775584377841e-09
alterparam dut ub = 1.622784352085465e-18
alterparam dut uc = 1*-5.914885649683927e-09
alterparam dut voff = 1*-0.0509119356254559
alterparam dut voffcv = 0.02534929607637293
alterparam dut vsat = 171574.1760831988
alterparam dut vth0 = 0.47660822951515414
alterparam dut w0 = 4.496173875055217e-07
alterparam dut wint = 1*-2.0276758950935778e-08
alterparam dut ww = 1*-2.194745469389403e-15
alterparam dut wwl = 1*-5.648454795313594e-20
alterparam dut lwl = 1*-6.643213509829941e-20
alterparam dut voffl = 1*-1.6691496054788685e-08
alterparam dut xpart = 0.6155841563121996
alterparam dut bin_pvsat = 0.5894512229181399
alterparam dut bin_prdsw = 0.2239714008503019
alterparam dut bin_ppclm = 0.4708017716422279
alterparam dut bin_wketa = 0.6155841563121996
alterparam dut bin_lketa = 0.7285280855853336
alterparam dut bin_pketa = 0.6155841563121996
alterparam dut bin_wk3 = 0.6155841563121996
alterparam dut bin_wk3b = 0.3370583571954646
reset
** Model parameters end

** Declare the vectors to save.
save i(v_s_21_1)

** Write the header of the results file.
echo "vgs,cgs_21_1" > /home/gazi/Desktop/Work/custom_packages/calibration/test/bsim4/results/calibration_2023-06-24_22:49:40/simulation_files/ac_list_0.csv

** Start the simulation loop.
set values_list = ( -2.0 -1.95 -1.8 -1.75 -1.7 -1.65 -1.6 -1.55 -1.5 -1.45 -1.4 -1.35 -1.3 -1.25 -1.2 -1.15 -1.1 -1.05 -1.0 -0.95 -0.9 -0.85 -0.8 -0.75 -0.7 -0.65 -0.6 -0.55 -0.5 -0.45 -0.4 -0.35 -0.3 -0.25 -0.2 -0.15 -0.1 -0.05 1.20737e-15 0.05 0.1 0.15 0.2 0.25 0.3 0.35 0.4 0.45 0.5 0.55 0.6 0.65 0.7 0.75 0.8 0.85 0.9 0.95 1.0 1.05 1.1 1.15 1.2 1.25 1.3 1.35 1.4 1.45 1.5 1.55 1.6 1.65 1.7 1.75 1.8 1.85 1.9 1.95 2.0 )
foreach val $values_list
    alter v_sweep $val
    ac lin 1 10000.0 10000.0

    let cgs_21_1 = abs(imag(i(v_s_21_1)))/2*pi*10000.0

    echo "$val,$&cgs_21_1" >> /home/gazi/Desktop/Work/custom_packages/calibration/test/bsim4/results/calibration_2023-06-24_22:49:40/simulation_files/ac_list_0.csv
end

.endc
********** End of control section **********

.end
