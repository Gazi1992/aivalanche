**********************************************************
* THIS FILE IS GENERATED BY AIVALANCHE
* FILE ID: 4
* SIMULATION TYPE: dc_sweep
**********************************************************

* Define the temperature
.TEMP 25

* Include the dut file
.INCLUDE ../../../src/templates/bsim4/nmos/dut.cir

** Start testbenches

********************* dut testbench 0_0 *********************
e_ds_0_0 d_0_0 0 v_sweep 0 1
v_gs_0_0 g_0_0 0 0.6
v_s_0_0 s_0_0 0 0
v_bs_0_0 b_0_0 0 -1.0
x_0_0 d_0_0 g_0_0 s_0_0 b_0_0 dut w=1e-05 l=1e-05 m=1
*************************************************************

********************* dut testbench 0_1 *********************
e_ds_0_1 d_0_1 0 v_sweep 0 1
v_gs_0_1 g_0_1 0 1.1
v_s_0_1 s_0_1 0 0
v_bs_0_1 b_0_1 0 -1.0
x_0_1 d_0_1 g_0_1 s_0_1 b_0_1 dut w=1e-05 l=1e-05 m=1
*************************************************************

********************* dut testbench 1_0 *********************
e_ds_1_0 d_1_0 0 v_sweep 0 1
v_gs_1_0 g_1_0 0 0.6
v_s_1_0 s_1_0 0 0
v_bs_1_0 b_1_0 0 0.0
x_1_0 d_1_0 g_1_0 s_1_0 b_1_0 dut w=1e-05 l=1e-05 m=1
*************************************************************

********************* dut testbench 1_1 *********************
e_ds_1_1 d_1_1 0 v_sweep 0 1
v_gs_1_1 g_1_1 0 1.35
v_s_1_1 s_1_1 0 0
v_bs_1_1 b_1_1 0 0.0
x_1_1 d_1_1 g_1_1 s_1_1 b_1_1 dut w=1e-05 l=1e-05 m=1
*************************************************************

********************* dut testbench 2_1 *********************
e_ds_2_1 d_2_1 0 v_sweep 0 1
v_gs_2_1 g_2_1 0 1.1
v_s_2_1 s_2_1 0 0
v_bs_2_1 b_2_1 0 -1.0
x_2_1 d_2_1 g_2_1 s_2_1 b_2_1 dut w=1e-05 l=1e-05 m=1
*************************************************************

** End testbenches

* Declare the v_sweep, which will change during the simulation.
v_sweep v_sweep 0 0
.dc v_sweep 0.0 1.6 0.1

********** Start of control section **********
.control

** Change model parameters.
alterparam dut a0 = 1.0
alterparam dut a1 = 0.0
alterparam dut a2 = 1.0
alterparam dut acde = 1.0
alterparam dut ags = 0.0
alterparam dut cf = 0.0
alterparam dut cgdl = 1e-10
alterparam dut cgdo = 1e-10
alterparam dut ckappas = 0.6
alterparam dut clc = 1e-07
alterparam dut cle = 0.6
alterparam dut dlc = 0.0
alterparam dut drout = 0.56
alterparam dut dsub = 0.56
alterparam dut dvt0 = 2.2
alterparam dut dvt0w = 0.0
alterparam dut dvt1 = 0.53
alterparam dut dvt1w = 5300000.0
alterparam dut dvt2 = 1*-0.032
alterparam dut dvt2w = 1*-0.032
alterparam dut dwg = 0.0
alterparam dut eta0 = 0.08
alterparam dut etab = 1*-0.07
alterparam dut k1 = 0.53
alterparam dut k2 = 1*-0.0186
alterparam dut k3 = 80.0
alterparam dut k3b = 0.0
alterparam dut keta = 1*-0.0047
alterparam dut lint = 0.0
alterparam dut ll = 0.0
alterparam dut moin = 15.0
alterparam dut ndep = 1e+17
alterparam dut nfactor = 1.0
alterparam dut ngate = 1e+20
alterparam dut noff = 1.0
alterparam dut pclm = 1.3
alterparam dut pdiblc1 = 0.39
alterparam dut pdiblc2 = 0.086
alterparam dut pdiblcb = 0.0
alterparam dut pvag = 0.0
alterparam dut rdsw = 200.0
alterparam dut toxp = 5e-09
alterparam dut u0 = 670.0
alterparam dut ua = 1e-09
alterparam dut ub = 1e-19
alterparam dut uc = 1*-4.65e-11
alterparam dut voff = 1*-0.08
alterparam dut voffcv = 0.0
alterparam dut vsat = 80000.0
alterparam dut vth0 = 0.5
alterparam dut w0 = 2.5e-06
alterparam dut wint = 0.0
alterparam dut ww = 0.0
alterparam dut wwl = 0.0
alterparam dut lwl = 0.0
alterparam dut voffl = 0.0
alterparam dut xpart = 0.0
alterparam dut bin_pvsat = 0.0
alterparam dut bin_prdsw = 0.0
alterparam dut bin_ppclm = 0.0
alterparam dut bin_wketa = 0.0
alterparam dut bin_lketa = 0.0
alterparam dut bin_pketa = 0.0
alterparam dut bin_wk3 = 0.0
alterparam dut bin_wk3b = 0.0
reset

** Run the simulation.
run

let ids_0_0 = i(v_s_0_0)
let vds_0_0 = v(d_0_0)
let ids_0_1 = i(v_s_0_1)
let vds_0_1 = v(d_0_1)
let ids_1_0 = i(v_s_1_0)
let vds_1_0 = v(d_1_0)
let ids_1_1 = i(v_s_1_1)
let vds_1_1 = v(d_1_1)
let ids_2_1 = i(v_s_2_1)
let vds_2_1 = v(d_2_1)

** Save the output to file.
set wr_vecnames
set wr_singlescale
wrdata /home/gazi/Desktop/Work/custom_packages/calibration/test/bsim4/results/dc_sweep_4.csv ids_0_0 vds_0_0 ids_0_1 vds_0_1 ids_1_0 vds_1_0 ids_1_1 vds_1_1 ids_2_1 vds_2_1

.endc
********** End of control section **********

.end
